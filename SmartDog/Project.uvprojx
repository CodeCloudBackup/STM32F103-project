# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\USER;.\CORE;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LED;.\HARDWARE\OLED;.\HARDWARE\SERVO;.\HARDWARE\SPI;.\HARDWARE\TIMER;.\HARDWARE\TOUCH;.\STM32F10x_FWLib\inc;.\Buletooth
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/SERVO/: servo.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/TOUCH/: touch.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./USER/: expression.c func.c main.c stm32f10x_it.c system_stm32f10x.c usart_protocol.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group LIBRARY
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
